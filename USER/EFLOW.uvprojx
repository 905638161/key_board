# Keil uVision project EFLOW.uvprojx, settings and files
target KM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: KM(2_1_0) +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\HARDWARE\24CXX;..\HARDWARE\IIC;..\HARDWARE\CH452;..\HARDWARE\DISPLAY;..\HARDWARE\LED;..\HARDWARE\USARTC;..\HARDWARE\KEY;..\HARDWARE\ADC;..\HARDWARE\TIMER;..\HARDWARE\DMA;..\HARDWARE\WT588D;..\HARDWARE\ENCODER;..\HARDWARE\IRAM;..\HARDWARE\SPO2;..\HARDWARE\TSC2046;..\HARDWARE\PWM
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c initall.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/USARTC/: usart.c DataHandle.c
    ../HARDWARE/WT588D/: wt588d.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/ENCODER/: encoder.c
    ../HARDWARE/IRAM/: iram.c
    ../HARDWARE/SPO2/: spo2.c
    ../HARDWARE/TSC2046/: tsc2046_spi.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/KEY/: key.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c
